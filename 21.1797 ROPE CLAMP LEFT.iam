# Autodesk Inventor assembly: 21.1797 ROPE CLAMP LEFT
## iProperties
Created: 2007-05
Part Number: 21.1797 ROPE CLAMP LEFT
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
